# Keil uVision project Project.uvprojx, settings and files
target Discover-More (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./bin/project.bin ./Discover-More/Project.axf
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\inc;..\..\..\Utilities\STM32F4-Discovery;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Utilities\FatFs_vR0.08a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery_sdio_sd.c stm32f4_discovery.c stm32f4_discovery_debug.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group FatFs
    ../../../Utilities/FatFs_vR0.08a/: diskio.c ff.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Readme
    ../: readme.txt
software components: CMSIS:CORE 5.0.0
